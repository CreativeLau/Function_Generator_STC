# Keil uVision project Function_Generator.uvproj, settings and files
target Function_Generator (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Function_Generator +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c STARTUP.A51 adc_stc15.c lcd1602.c settings.c delay.c config_stc.h wave.c
